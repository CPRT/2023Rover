Commit message: change urdf

File: src/test_urdf_tool/urdf/urdf_ARM-3000.urdf (robot description, URDF)
Before this commit: robot urdf_ARM-3000, 8 links, 7 joints
Joints:
- joint base_footprint_joint: child base_link -> Link_1
